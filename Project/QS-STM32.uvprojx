# Keil uVision project QS-STM32.uvprojx, settings and files
target QS-STM32 (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: QS-STM32_V10 +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS;..\Libraries\Startup;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\App;..\Bsp;..\Device
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Startup
    ../Libraries/Startup/: startup_stm32f10x_hd.s
  group App
    ../App/: main.c stm32f10x_it.c Timer.c BoardVariable.c operateA.c operateB.c Function.c ConvertPoint.c
  group Device
    ../Device/: adjust.c mbcrc.c i2c.c as5600.c syn6288.c adc.c Keypad.c
  group Bsp
    ../Bsp/: bsp.c sys.c delay.c USART.c UART_Control.c UART_Camera.c UART_485.c UART_TFTLCD.c
  group Cortex-M3
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group StdPeriphDriver
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
software components: CMSIS:CORE 5.5.0
